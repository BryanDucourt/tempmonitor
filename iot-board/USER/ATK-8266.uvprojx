# Keil uVision project ATK-8266.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ATK-8266 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ..\CORE;..\FATFS\exfuns;..\FATFS\src;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\HALLIB\STM32L4xx_HAL_Driver\Inc\Legacy;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\MALLOC;..\HARDWARE\QSPI;..\HARDWARE\SD_CARD;..\HARDWARE\SPI3;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\HARDWARE\SPI1;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEXT;..\USER;..\USMART;..\HARDWARE\USART2;..\ATK_ESP8266;..\HARDWARE\AHT10;..\HARDWARE\MYIIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./: main.c stm32l4xx_it.c system_stm32l4xx.c
  group CORE
    ../CORE/: startup_stm32l475xx.s
  group HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_ltdc.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/SD_CARD/: sd_card.c
    ../HARDWARE/SPI3/: spi3.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI1/: spi1.c
    ../HARDWARE/AHT10/: aht10.c
    ../HARDWARE/MYIIC/: myiic.c
  group FATFS
    ../FATFS/exfuns/: fattester.c mycc936.c exfuns.c
    ../FATFS/src/: ff.c diskio.c
  group TEXT
    ../TEXT/: text.c fontupd.c
  group USMART
    ../USMART/: usmart_str.c usmart.c usmart_config.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group ATK-8266
    ../ATK_ESP8266/: apsta.c common.c wifiap.c wifista.c
